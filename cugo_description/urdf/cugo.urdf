Commit message: urdfの修正

File: cugo_description/urdf/cugo.urdf (robot description, URDF)
Before this commit: robot cugo, 5 links, 4 joints
Links:
- removed link laser
- added link laser_frame
Joints:
- joint scan_joint: child laser -> laser_frame
